# Keil uVision project ISP_USCI_UART.uvprojx, settings and files
target ISP_USCI_UART (6190000::V6.19::ARMCLANG)
  device: Mini57TDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x75FF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ISP_USCI_UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\Mini57Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7600
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini57_ISP2.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/: system_Mini57Series.c
    ../: startup_Mini57_ISP2.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c usci_uart_transfer.c
