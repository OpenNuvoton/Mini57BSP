# Keil uVision project ISP_USCI_I2C.uvproj, settings and files
target ISP_USCI_I2C (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Mini57TDE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x75FF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ISP_USCI_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini57Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7600
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini57_ISP.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/: system_Mini57Series.c
    ../: startup_Mini57_ISP.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c usci_i2c_transfer.c
