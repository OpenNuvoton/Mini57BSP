# IAR project TIMER_EventCounter.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini57DE series Nuvoton Mini57DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\Mini57Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_EventCounter.bin
  ILINK.IlinkOutputFile: TIMER_EventCounter.out
  ILINK.IlinkIcfFile: TIMER_EventCounter.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/IAR/: startup_Mini57Series.s
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/: system_Mini57Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c usci_uart.c
  group User
    ../: main.c
