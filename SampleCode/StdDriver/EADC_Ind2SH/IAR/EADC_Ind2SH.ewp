# IAR project EADC_Ind2SH.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini57DE series Nuvoton Mini57DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include\; ..\..\..\..\Library\StdDriver\inc\; ..\..\..\..\Library\Device\Nuvoton\Mini57Series\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EADC_Ind2SH.bin
  ILINK.IlinkOutputFile: EADC_Ind2SH.out
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/IAR/: startup_Mini57Series.s
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/: system_Mini57Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c eadc.c gpio.c retarget.c sys.c usci_uart.c
  group User
    ../: main.c
