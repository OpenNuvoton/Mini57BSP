<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EADC_SimSeq3R.ewp</path>
  </project>
  <batchBuild/>
</workspace>


