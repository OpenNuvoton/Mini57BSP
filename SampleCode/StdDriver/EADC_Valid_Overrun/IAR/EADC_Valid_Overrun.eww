<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EADC_Valid_Overrun.ewp</path>
  </project>
  <batchBuild/>
</workspace>


