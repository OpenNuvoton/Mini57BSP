# Keil uVision project USCI_UART_AutoBaudRate_Master.uvprojx, settings and files
target USCI_UART_AutoBaudRate_Master (ARM-ADS)
  device: Mini57TDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x75FF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USCI_UART_AutoBaudRate_Master
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\Mini57Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7600
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini57Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/: system_Mini57Series.c
    ../../../../Library/Device/Nuvoton/Mini57Series/Source/ARM/: startup_Mini57Series.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c usci_uart.c gpio.c
  group User
    ../: main.c
