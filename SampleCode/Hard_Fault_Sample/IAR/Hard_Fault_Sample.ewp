# IAR project Hard_Fault_Sample.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Mini57DE series Nuvoton Mini57DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\Mini57Series\Include; ..\..\..\Library\StdDriver\Inc; ..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hard_Fault_Sample.bin
  ILINK.IlinkOutputFile: Hard_Fault_Sample.out
  ILINK.IlinkIcfFile: Hard_Fault_Sample.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Mini57Series/Source/IAR/: startup_Mini57Series.s
    ../../../Library/Device/Nuvoton/Mini57Series/Source/: system_Mini57Series.c
  group Libraries
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c usci_uart.c
  group User
    ../: main.c
