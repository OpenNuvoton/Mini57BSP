<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PGA_PGAO.ewp</path>
  </project>
  <batchBuild/>
</workspace>


